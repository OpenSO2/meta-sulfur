#LICENSE = "GPL-2+"
#EXTRAPATHS := "${THISDIR}/${PN}:"
#ASRC_URI += " file://fstab.patch "
FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
